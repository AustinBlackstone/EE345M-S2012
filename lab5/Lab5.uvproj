# Keil uVision project Lab5.uvproj, settings and files
target OLED (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab2
  c flags: Optim=1
  c include: ..;..\..;..\driverlib;\..\EE345M;..\driverlib\rvmdk;..\..\EE345M-S2012;..\Lab2;..\..\EE345M-S2012
  asm include: ..;..\..;..\driverlib;\..\EE345M;..\driverlib\rvmdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ../: Startup.s rit128x96x4.c adc.c uart.c edisk.c edisk.h efile.h debug.c
    ./: os.c os_asm.s Lab5.c efile.c
  group Libraries
    ../driverlib/rvmdk/: driverlib.lib
