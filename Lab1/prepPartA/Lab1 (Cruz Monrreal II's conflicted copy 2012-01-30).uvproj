# Keil uVision project Lab1 (Cruz Monrreal II's conflicted copy 2012-01-30).uvproj, settings and files
target OLED (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab1
  c flags: Optim=1
  c include: ..;..\..\..;..\..\driverlib;..\..\..\EE345M
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s rit128x96x4.c OLED_SplitScreen.c OLED_SplitScreen_TestMain.c adc.c uart.c ringbuffer.c
  group Libraries
    D:/Dropbox/S2012/EE345M/driverlib/rvmdk/: driverlib.lib
