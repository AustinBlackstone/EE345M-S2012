# Keil uVision project Lab2.uvproj, settings and files
target OLED (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab2
  c flags: Optim=1
  c include: ..;..\..;..\driverlib;\..\EE345M;..\driverlib\rvmdk;..\..\EE345M-S2012;..\Lab2;..\..\EE345M-S2012
  asm include: ..;..\..;..\driverlib;\..\EE345M;..\driverlib\rvmdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    C:/Users/Cruz Monrreal II/Desktop/EE345M-S2012/: Startup.s rit128x96x4.c
    ./: os.c Lab2.c os_asm.s cr4_fft_64_stm32.s PID_stm32.s
    ../: adc.c uart.c
  group Libraries
    C:/Users/Cruz Monrreal II/Desktop/EE345M-S2012/driverlib/rvmdk/: driverlib.lib
